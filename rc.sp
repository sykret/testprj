* title
r_1_2 n8 n1 1.0000000000e+03
c_1_2 n8 n1 -2.5000000000e-13
c_1_0 n8 0 5.0000000000e-13
c_2_0 n1 0 5.0000000000e-13
